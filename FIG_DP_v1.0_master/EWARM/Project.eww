<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\FIG_DP_v1.0_master.ewp</path>
  </project>
  <batchBuild />
</workspace>
